# Keil uVision project at32f425_usb_bootloader.uvprojx, settings and files
target bootloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F425K8T7 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.0.7
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: at32f425_usb_bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F425R8T7,USE_STDPERIPH_DRIVER,AT_TAOBAO_F425
  c include: .\app\include;.\lib\include\cmsis;.\lib\include;.\usb\class\include;.\usb\driver\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./app/src/: at32f425_board.c at32f425_clock.c at32f425_int.c hid_iap_user.c main.c
  group usb
    ./usb/class/src/: hid_iap_class.c hid_iap_desc.c
    ./usb/driver/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group lib
    ./lib/src/: at32f425_acc.c at32f425_crc.c at32f425_crm.c at32f425_exint.c at32f425_flash.c at32f425_gpio.c at32f425_misc.c at32f425_usb.c
  group cmsis
    ./lib/src/cmsis/: system_at32f425.c
    ./lib/src/cmsis/mdk/: startup_at32f425.s
